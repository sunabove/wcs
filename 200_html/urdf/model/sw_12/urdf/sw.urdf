Commit message: ㅁㅁ

File: 200_html/urdf/model/sw_12/urdf/sw.urdf (robot description, URDF)
Before this commit: robot sw5, 30 links, 29 joints
Joints:
- joint ground_to_rock_1_joint: origin xyz=1.801 0.772 0.04 rpy=0 0 0 -> xyz=1.801 0.315 0.04 rpy=0 0 0
